# IAR project simple_peripheral_oad_offchip_CC1352P_4_LAUNCHXL_tirtos7_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  postbuild: $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/tools/ble5stack/oad/oad_postbuild.bat $TARGET_BPATH$ $PROJ_DIR$ $CONFIG_NAME$ $PROJ_FNAME$ $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$ $EXE_DIR$ $TARGET_BNAME$
configuration Debug (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: simple_peripheral_oad_offchip_CC1352P_4_LAUNCHXL_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
