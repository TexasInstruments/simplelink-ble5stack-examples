<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/persistent_app_CC1352P_4_LAUNCHXL_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>