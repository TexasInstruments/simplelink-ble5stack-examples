<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/host_test_LP_EM_CC2674P10_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>