<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/simple_central_LP_CC1352P7_4_tirtos7_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>