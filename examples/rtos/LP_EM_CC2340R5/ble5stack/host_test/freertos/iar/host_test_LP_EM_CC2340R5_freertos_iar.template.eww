<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/host_test_LP_EM_CC2340R5_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>