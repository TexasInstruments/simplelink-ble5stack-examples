<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/basic_ble_ptm_LP_EM_CC2340R5_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>