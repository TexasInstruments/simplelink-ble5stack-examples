# IAR project basic_ble_oad_offchip_LP_EM_CC2340R5_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  postbuild: $COM_TI_SIMPLELINK_LOWPOWER_F3_SDK_INSTALL_DIR$/tools/ble5stack/oad/iar_app_offchip_postbuild $COM_TI_SIMPLELINK_LOWPOWER_F3_SDK_INSTALL_DIR$ $TARGET_BPATH$ 0x76000
configuration Debug (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: basic_ble_oad_offchip_LP_EM_CC2340R5_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
