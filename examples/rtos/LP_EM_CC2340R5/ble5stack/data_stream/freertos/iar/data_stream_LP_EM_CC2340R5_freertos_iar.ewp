# IAR project data_stream_LP_EM_CC2340R5_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  postbuild: $COM_TI_SIMPLELINK_LOWPOWER_F3_SDK_INSTALL_DIR$/tools/ble5stack/cc23r5_iar/cc23r5_iar_postbuild.bat $TARGET_BPATH$ $TARGET_PATH$
configuration Debug (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: data_stream_LP_EM_CC2340R5_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
