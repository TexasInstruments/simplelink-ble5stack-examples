# IAR project stack_wrapper.ewp, settings and files
configuration Stack_Wrapper (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -f ..\..\Stack_Wrapper.opt; --aeabi; -f $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\config\build_components.opt; -f $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\config\factory_config.opt; -f $BUILD_CONFIG_DIR$\build_config.opt; --diag_suppress=Pa050; --make_all_definitions_weak
  ICCARM.CCIncludePath2: $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\controller\cc26xx\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\rom; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\common\cc26xx\npi\stack; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\icall\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target\_common; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\hal\src\target; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\icall\src\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\npi\src; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\osal\src\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\common\nv; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\services\src\saddr; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\kernel\tirtos7\packages; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\rf_patches; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\cc13x2_cc26x2\inc; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  ILINK.IlinkOutputFile: stack_wrapper.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=2; CC2650=2
  ILINK.IlinkProgramEntryLabel: startup_entry
configuration Stack_Wrapper_13r1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC1352R1F3 TexasInstruments CC1352R1F3
  ICCARM.IExtraOptions: -f ..\..\Stack_Wrapper_13r1.opt; --aeabi; -f $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\config\build_components.opt; -f $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\config\factory_config.opt; -f $BUILD_CONFIG_DIR$\build_config.opt; --diag_suppress=Pa050; --make_all_definitions_weak
configuration Stack_Wrapper_13p2 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC1352P1F3 TexasInstruments CC1352P1F3
  ICCARM.IExtraOptions: -f ..\..\Stack_Wrapper_13p2.opt; --aeabi; -f $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\config\build_components.opt; -f $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$\source\ti\ble5stack\config\factory_config.opt; -f $BUILD_CONFIG_DIR$\build_config.opt; --diag_suppress=Pa050; --make_all_definitions_weak
  group HAL/API
    ../../../../../../../source/ti/ble5stack/hal/src/target/_common/: crypto_api.h ecc_api.h rf_api.h rtos_drivers.h trng_api.h
  group HAL/Common
    ../../../../../../../source/ti/ble5stack/hal/src/common/: hal_assert.c
  group HAL/Include
    ../../../../../../../source/ti/ble5stack/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    ../../../../../../../source/ti/ble5stack/hal/src/target/_common/: hal_mcu.h mb.h rf_hal.h
  group HAL/Target/CC2650/Config
    ../../../../../../../source/ti/ble5stack/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    ../../../../../../../source/ti/ble5stack/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group Host
    ../../../../../../../source/ti/ble5stack/host/: gap.c gapbondmgr.c gatt_uuid.c gattservapp_util.c rtls_srv.c sm_ecc.c
    ../../../../../../../source/ti/ble5stack/inc/: gapbondmgr.h gapgattserver.h gatt_uuid.h gattservapp.h rtls_srv_api.h
  group ICallBLE
    ../../../../../../../source/ti/ble5stack/icall/inc/: ble_dispatch.h
    ../../../../../../../source/ti/ble5stack/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    ../../../../../../../source/ti/ble5stack/icall/src/: icall_lite_translation.c
  group NPI
    ../../../../../../../source/ti/ble5stack/common/cc26xx/npi/stack/: npi.c
  group OSAL
    ../../../../../../../source/ti/ble5stack/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_list.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    ../../../../../../../source/ti/ble5stack/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_list.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    ../../../../../../../source/ti/ble5stack/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group ROM
    ../../../../../../../source/ti/ble5stack/rom/agama_r1/: common_rom_init.c rom_flash_jt.h
  group Startup
    ../../../../../../../source/ti/ble5stack/common/cc26xx/: icall_startup.c
  group Tools
    ../../../../../../../source/ti/ble5stack/config/: build_components.opt
    ../../: build_config.opt
    ../../../../../../../source/ti/ble5stack/common/cc26xx/: onboard.c onboard.h
  group Tools/defines
    ../../: Stack_Wrapper.opt Stack_Wrapper_13p2.opt Stack_Wrapper_13r1.opt
