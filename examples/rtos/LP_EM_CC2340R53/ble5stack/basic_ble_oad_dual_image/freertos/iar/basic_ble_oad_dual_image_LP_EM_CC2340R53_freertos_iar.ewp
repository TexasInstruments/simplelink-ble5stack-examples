# IAR project basic_ble_oad_dual_image_LP_EM_CC2340R53_freertos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
configuration Debug (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: basic_ble_oad_dual_image_LP_EM_CC2340R53_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
