<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/basic_ble_LP_EM_CC1354P10_1_freertos_iar.ewp</path>
    </project>
    <project>
        <path>release/iar/freertos_builds_LP_EM_CC1354P10_1_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>