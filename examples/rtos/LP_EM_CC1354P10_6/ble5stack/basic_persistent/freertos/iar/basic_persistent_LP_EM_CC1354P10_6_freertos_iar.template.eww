<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/basic_persistent_LP_EM_CC1354P10_6_freertos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>